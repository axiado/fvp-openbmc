SRCREV = "8eda821874fc26aa22090124000cc61ba358bc01"
SRC_URI = "git://git.gitlab.arm.com/server_management/bmcweb.git;branch=fvp_devel;protocol=https"
