EXTRA_OEMESON:append = " \
    -Dredfish-dump-log=enabled \
"

EXTRA_OEMESON = " \
  -Dhttp2=disabled \
"

