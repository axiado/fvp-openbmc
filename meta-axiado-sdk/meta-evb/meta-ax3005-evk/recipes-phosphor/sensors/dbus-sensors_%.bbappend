FILESEXTRAPATHS:prepend:evk-ax3005-fvp := "${THISDIR}/files:"
FILESEXTRAPATHS:prepend:evk-ax3005-fvp-github := "${THISDIR}/files:"
